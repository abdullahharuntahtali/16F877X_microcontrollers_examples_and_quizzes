#INCLUDE <P16F877A.INC>
	ORG 0X00
MAIN
	BANKSEL TRISC
	BSF TRISC,7
	CLRF TRISD
	BANKSEL PORTC
	CLRF PORTC
	CLRF PORTD
	BANKSEL SPBRG
	MOVLW D'25'
	MOVWF SPBRG
	BANKSEL TXSTA
	MOVLW B'00100100'
	MOVWF TXSTA
	BANKSEL RCSTA
	MOVLW B'10010000'
	MOVWF RCSTA
KONTROL
	BANKSEL PIR1
	BTFSC PIR1,RCIF   ;BÝLGÝ ALINDIMI(GELDÝMÝ)
	GOTO YAZ
	MOVLW H'6'
	ANDWF RCSTA,W
	BTFSS STATUS,Z
	BCF RCSTA,4
	BSF RCSTA,4
YAZ
	MOVFW RCREG
	MOVWF PORTD
	GOTO KONTROL
	END
	