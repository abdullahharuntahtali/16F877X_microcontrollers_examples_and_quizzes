#INCLUDE <P16F877A.INC>
SAYAC EQU 0X20
	ORG 0X00
MAIN
	BANKSEL TRISC
	BSF TRISC,6
	BANKSEL PORTC
	CLRF PORTC
	BANKSEL SPBRG
	MOVLW D'25'
	MOVWF SPBRG
	BANKSEL TXSTA
	MOVLW B'00100100'
	MOVWF TXSTA
	BANKSEL RCSTA
	BSF RCSTA,7
KONTROL
	BANKSEL PIR1
	BTFSS PIR1,TXIF
	GOTO KONTROL
	MOVLW 'S'
	MOVWF TXREG
	CALL GECIKME
	CALL GECIKME
	MOVLW 'O'
	MOVWF TXREG
	CALL GECIKME
	CALL GECIKME
	MOVLW 'S'
	MOVWF TXREG
	CALL GECIKME
	CALL GECIKME
	GOTO KONTROL
GECIKME
	MOVLW D'255'
	MOVWF SAYAC
GECIKTIR
	DECFSZ SAYAC,F
	GOTO GECIKTIR
	RETURN
	END