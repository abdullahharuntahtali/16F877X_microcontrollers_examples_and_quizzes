	List P = 16F84
	#include <p16F84.inc>
	__CONFIG 1Bh    ;_CP_OFF & _PWRTE_ON & _WDT_OFF & _RC_OSC


	ORG 0 
SetUp   BSF 03,5
	CLRF 06
	MOVLW 10h
	MOVWF 05
	BCF 03,5
	CLRF 05
	GOTO Main1

Table 
	ADDWF 02h,1
	RETLW 3Fh
	RETLW 06h
	RETLW 5Bh
	RETLW 4Fh
	RETLW 66h
	RETLW 6Dh
	RETLW 7Dh
	RETLW 07h
	RETLW 7Fh
	RETLW 6Fh 
 
Clear   MOVLW 80h
	MOVWF 1B
	CLRF 06
	CALL Delay
	RETURN

Delay	NOP
	NOP
	DECFSZ 1A,1
	GOTO Delay
	DECFSZ 1B,1
	GOTO Delay
	RETURN

Inc	INCF 11h,1
	MOVLW 0A
	XORWF 11h,0
	BTFSS 03,2
	RETURN
	CLRF 11h
	INCF 12h,1
	MOVLW 0A
	XORWF 12h,0
	BTFSS 03,2
	RETURN
	CLRF 12h
	INCF 13h,1
	MOVLW 0A
	XORWF 13h,0
	BTFSS 03,2
	RETURN
	CLRF 13h
	RETURN


Look	CLRF 0C
	BSF 06,7
Look2	NOP
	INCF 0C,1
	BTFSC 05,4
	GOTO Look2
	BCF 06,7
	RETURN

Main	MOVF 13h,0
	CALL Table
	MOVWF 06
	CALL Delay
	CALL Clear
	MOVF 12h,0
	CALL Table
	MOVWF 06
	CALL Delay
	CALL Clear
	MOVF 11h,0
	CALL Table
	MOVWF 06
	CALL Delay
	CALL Clear
	MOVLW 3Fh
	MOVWF 06
	CALL Delay
	CALL Clear
	CALL Delay
	CALL Delay

Main1	CLRF 11h
	CLRF 12h
	CLRF 13h
	CALL Look
	MOVLW 04
	MOVWF 0F

Main2	MOVF 0C,0
	MOVWF 0E

Main3   DECFSZ 0E,1
	GOTO Main4
	DECFSZ 0F,1
	GOTO Main2
	GOTO Main
Main4 	CALL Inc
   	GOTO Main3
	END 