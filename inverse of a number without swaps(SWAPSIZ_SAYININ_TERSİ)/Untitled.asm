#INCLUDE <P16F877A.INC>
__CONFIG H'3F31'
SAYAC1 EQU 0X20
SAYAC2 EQU 0X21
LCD_DATA EQU 0X22
SAYAC EQU 0X23
SAYI EQU 0X24
DORT EQU 0X26
	ORG 0X00
MAIN
YAZDIR
	MOVLW H'FA'
	MOVWF SAYI
	MOVLW D'7'
	MOVWF DORT
	CALL SOL
	MOVLW H'FA'
	MOVWF SAYI
	MOVLW D'4'
	MOVWF DORT	
	CALL SAG
	GOTO YAZDIR
SOL
	MOVFW SAYI
	ANDLW B'00001111'
	MOVWF SAYI
	RETURN
SAG
	RRF SAYI
	DECFSZ DORT,F
	GOTO SAG
	MOVFW SAYI
	ANDLW B'00001111'
	MOVWF SAYI
	RETURN
	END
