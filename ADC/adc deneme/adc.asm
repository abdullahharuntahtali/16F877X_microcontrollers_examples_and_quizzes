#include <p16f877a.inc>
__config h'3f31'

ORG 0X00
GOTO BASLA
ORG 0X04

KESME
BTFSS PIR1,ADIF
RETFIE
BTFSC ADCON0,2 ;GO/DONE
RETFIE
BCF PIR1,ADIF
BSF ADCON0,2
MOVF ADRESH,W
MOVWF PORTB
RETFIE

BASLA
BANKSEL TRISE
MOVLW d'255'
MOVWF TRISE
CLRF TRISB	

BSF INTCON,GIE
BSF INTCON,PEIE
BSF PIE1,ADIE

BSF ADCON1,ADCS2 ;osýlator
BCF ADCON1,ADFM ;sola dayalý
BANKSEL PORTB
CLRF PORTA
CLRF PORTB
MOVLW B'11101101' ;GO
MOVWF ADCON0
BCF PIR1,ADIF

BEKLE
GOTO BEKLE

END